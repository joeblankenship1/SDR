<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_uchar_to_float</key>
<param><key>id</key><value>gr_uchar_to_float_0</value></param>
</block>
<block>
<key>gr_uchar_to_float</key>
<param><key>id</key><value>gr_uchar_to_float_1</value></param>
</block>
<block>
<key>gr_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-127</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.008</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.008</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blks2_wfm_rcv_pll</key>
<param><key>id</key><value>blks2_wfm_rcv_pll_0</value></param>
<param><key>quad_rate</key><value>2000000</value></param>
<param><key>audio_decimation</key><value>40</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>/home/al/Desktop/fm/output.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/al/Downloads/rtl2832u_fm_sample_FIXED.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_uchar_to_float_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_uchar_to_float_0</source_block_id><sink_block_id>gr_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_uchar_to_float_1</source_block_id><sink_block_id>gr_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_1</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>blks2_wfm_rcv_pll_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_pll_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_pll_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_pll_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_pll_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
